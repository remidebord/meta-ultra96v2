LIC_FILES_CHKSUM = "file://devmem2.c;endline=38;md5=81c9a77ea190f1da3c0b95701f11fcff"

# Use enhanced version of devmem2
SRC_URI = "git://github.com/remidebord/devmem2;protocol=https;branch=master"
SRCREV = "7b4abff62defe881b59869ac954d24cca8dddfa2"

