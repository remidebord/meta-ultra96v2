FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# See machine configuration for hdf path
#HDF_BASE_example-zcu102-zynqmp = "file://"
#HDF_PATH_example-zcu102-zynqmp = "design_1_wrapper.xsa"
